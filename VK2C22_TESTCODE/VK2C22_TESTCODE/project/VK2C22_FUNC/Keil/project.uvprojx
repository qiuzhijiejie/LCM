# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M451VE6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: test_lcdic_v10 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\Library\StdDriver\inc;..\Bsp;..\User;..\lcd_driver;..\exti_driver;..\led_driver;..\touch;..\dotmatix_lcd;..\KH
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ../User/: main.c
  group LCD_DRIVER
    ../lcd_driver/: VK2C22_IO_I2C_QUASI.c VK2C22_IO_I2C_DIR.c VK2C22_IO_I2C.c
  group Bsp
    ../Bsp/: board.c
  group Library
    ../../../Library/StdDriver/src/: clk.c timer.c sys.c retarget.c gpio.c pwm.c i2c.c
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
software components: CMSIS:CORE 5.4.0
