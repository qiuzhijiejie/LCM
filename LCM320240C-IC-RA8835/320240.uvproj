# Keil uVision project 320240.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 320240 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 320240.c 320240.h pic.c pic.h
