# Keil uVision project TPR-786696.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TPR-786696 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 TPR-786696.C mian.c Pic.c Pic.h LCM13264(COG).c LCM13264(COG).h
